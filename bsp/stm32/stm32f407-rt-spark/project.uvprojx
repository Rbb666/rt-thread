# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, STM32F407xx, RT_USING_ARMLIBC, USE_HAL_DRIVER, __RTTHREAD__, __STDC_LIMIT_MACROS
  c include: packages\stm32f4_cmsis_driver-latest\Include;..\..\..\components\drivers\include;packages\stm32f4_hal_driver-latest\Inc\Legacy;board\ports;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\ipc;board;packages\stm32f4_hal_driver-latest\Inc;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\compilers\common\extension;..\libraries\HAL_Drivers;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;board\CubeMX_Config\Inc;..\..\..\libcpu\arm\cortex-m4;..\..\..\libcpu\arm\common;..\..\..\components\drivers\phy;..\libraries\HAL_Drivers\drivers;..\..\..\components\net\utest;..\..\..\components\drivers\include;packages\CmBacktrace-latest;applications;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\..\..\components\libc\posix\io\poll;packages\CMSIS-Core-latest\Include;.;..\..\..\components\libc\compilers\common\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group cm_backtrace
    packages/CmBacktrace-latest/: cm_backtrace.c cmb_flash_log.c cmb_port.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_dma.c drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group STM32F4-CMSIS
    packages/stm32f4_cmsis_driver-latest/Source/Templates/: system_stm32f4xx.c
    packages/stm32f4_cmsis_driver-latest/Source/Templates/arm/: startup_stm32f407xx.s
  group STM32F4-HAL
    packages/stm32f4_hal_driver-latest/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c
